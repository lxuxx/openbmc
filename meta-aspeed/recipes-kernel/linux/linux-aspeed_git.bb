# openbmc
#KBRANCH ?= "dev-5.7"
#LINUX_VERSION ?= "5.7.10"
#SRCREV="666e403461fd046b37bc95bba49e82ca6a758bea"
# aspeed
KBRANCH ?= "aspeed-master-v5.1"
LINUX_VERSION ?= "5.1.3"
SRCREV="d3603a319eb1aa1295537f22b6855f759f47f70c"

require linux-aspeed.inc
